ORG 0000H
   	LJMP MAIN
ORG 0030H
	
MAIN:
	MOV TCON,#20H     ;TIMER 1 MODE 2
	MOV TH1,#0FDH	  ;BAUD RATE 9600
	MOV SCON,#50H 	  ;SERIAL CCOMMUNICATION
	SETB TR1    	  ; START TIMER-1
	
UP: MOV A,#'H'
	ACALL SEND
	MOV A,#'e'
	ACALL SEND
	MOV A,#'l'
	ACALL SEND
	MOV A,#'l'
	ACALL SEND
	MOV A,#'o'
	ACALL SEND
	MOV A,#' '
	ACALL SEND
	SJMP $

SEND: MOV SBUF,A
AGN	:JNB TI , AGN
CLR TI
RET
END